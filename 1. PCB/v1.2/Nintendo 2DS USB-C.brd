File: 1. PCB/v1.2/Nintendo 2DS USB-C.brd (EAGLE design)
At the start: 11.9 x 6.7 mm, 9 parts, among them J1 USBC-C668623

Commit message: no message
Routing:
- net GND: track 53.9 -> 80.6 mm
